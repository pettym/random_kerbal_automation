options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable
  parameters:
    value: (1.0,-0.8997054074213576)
  states: {}
- name: b
  id: variable
  parameters:
    value: (0.05014729628932114,0.05014729628932114)
  states: {}
- name: dc_block
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-129.8'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-4'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wm/python/kerbal_hid/filter_testing/record.floats
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.032520325203252'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '9'
    init: '0'
    low: '9'
  states: {state: disabled}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '5'
    init: '0'
    low: '5'
  states: {}
- name: blocks_threshold_ff_2
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4
    type: float
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: a
    fftaps: b
    oldstyle: 'False'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    color1: red
    color2: blue
    ctrlpanel: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.01'
    tr_level: '0.7'
    type: float
    update_time: '0.25'
    ymax: '128'
    ymin: '-128'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.25'
    alpha2: '0.9'
    alpha3: '0.9'
    color1: black
    color2: blue
    color3: red
    ctrlpanel: 'True'
    grid: 'True'
    label1: Raw
    label2: Filter 1
    label3: Filter 2
    nconnections: '3'
    size: '1000'
    srate: samp_rate
    tr_delay: '0.01'
    tr_level: '0.7'
    type: float
    update_time: '0.25'
    ymax: '128'
    ymin: '-128'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: filter_1
  states: {state: disabled}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: filter_1
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: filter_2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: filter_2
  states: {state: disabled}
- name: virtual_source_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: filter_2
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: filter_1
  states: {state: disabled}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: filter_1
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_threshold_ff_2, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_1, '0', blocks_multiply_xx_1, '1']
- [blocks_threshold_ff_2, '0', blocks_multiply_xx_1_0, '1']
- [blocks_throttle_0, '0', blocks_add_const_vxx_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_add_const_vxx_1, '0']
- [iir_filter_xxx_0_0, '0', blocks_add_const_vxx_1_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [iir_filter_xxx_0_0, '0', blocks_threshold_ff_1, '0']
- [iir_filter_xxx_0_0, '0', virtual_sink_1_0_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [virtual_source_1_0, '0', blocks_abs_xx_0, '0']
- [virtual_source_1_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_1_0_0, '0', iir_filter_xxx_0_0, '0']
- [virtual_source_2_0_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [virtual_source_2_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [virtual_source_2_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [virtual_source_2_1_0, '0', qtgui_time_sink_x_0_0_0_0, '1']

metadata:
  file_format: 1
