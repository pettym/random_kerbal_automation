options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable
  parameters:
    value: '[1.0,-1.946074986119715,0.9470357307185884]'
  states: {}
- name: b
  id: variable
  parameters:
    value: '[0.0002401861497183427,0.0004803722994366854,0.0002401861497183427]'
  states: {}
- name: hilbert_taps
  id: variable
  parameters:
    value: '65'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ratio
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-256'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./record2.floats
    repeat: 'False'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '3'
    init: '0'
    low: '3'
  states: {state: disabled}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '6'
    init: '0'
    low: '2'
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0.05'
    init: '0'
    low: '0.001'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: interp
    taps: '[1]'
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp
    taps: '[1/ratio]*(interp*ratio)'
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp
    taps: '[1]*interp'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: interp
    taps: '[1,-1]'
    type: fff
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15'
    decim: interp
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '15'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1'
    decim: interp
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '4'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.9'
    alpha3: '0.9'
    color1: black
    ctrlpanel: 'True'
    grid: 'True'
    label1: Raw
    label2: Filter_0
    label3: filter_1
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '128'
    ymin: '-128'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.1'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: filter_0
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: filter_0
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: filter_1
  states: {state: disabled}
- name: virtual_sink_2_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: filter_1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: fast_filter_enable
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: slow_filter_enable
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: monitor_filter_0
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: monitor_filter_1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: filter_0
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: filter_1
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_2_1
  id: virtual_source
  parameters: {}
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: fast_filter_enable
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: slow_filter_enable
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: slow_filter_enable
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: fast_filter_enable
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: monitor_filter_1
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: monitor_filter_0
  states: {}

connections:
- [analog_const_source_x_0, '0', virtual_sink_2, '0']
- [analog_const_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_const_source_x_1_0, '0', blocks_multiply_xx_0, '1']
- [blocks_abs_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_abs_xx_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_abs_xx_1, '0', virtual_sink_4, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_abs_xx_1, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_1, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_delay_1_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_xx_1, '0', virtual_sink_2_0_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_threshold_ff_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_threshold_ff_0_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_threshold_ff_1, '0', virtual_sink_3, '0']
- [blocks_throttle_0, '0', blocks_add_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_0, '0']
- [fir_filter_xxx_0, '0', virtual_sink_5, '0']
- [fir_filter_xxx_0_0, '0', virtual_sink_1_0, '0']
- [interp_fir_filter_xxx_0_0, '0', fir_filter_xxx_0_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', low_pass_filter_0, '0']
- [interp_fir_filter_xxx_0_0_1, '0', blocks_abs_xx_0, '0']
- [low_pass_filter_0, '0', fir_filter_xxx_0, '0']
- [low_pass_filter_0_0, '0', single_pole_iir_filter_xx_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_threshold_ff_1, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_multiply_xx_1, '0']
- [single_pole_iir_filter_xx_1, '0', virtual_sink_6, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1, '0', blocks_add_xx_1, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_1_0, '0', blocks_add_xx_1, '1']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_2, '0', blocks_delay_1, '0']
- [virtual_source_2_0, '0', interp_fir_filter_xxx_0_0, '0']
- [virtual_source_2_0_0, '0', interp_fir_filter_xxx_0_0_1, '0']
- [virtual_source_2_1, '0', blocks_delay_1_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_0, '1']
- [virtual_source_3_0, '0', blocks_multiply_xx_1, '1']
- [virtual_source_3_0_0, '0', blocks_null_sink_0, '0']
- [virtual_source_3_1, '0', blocks_null_sink_0_0, '0']
- [virtual_source_4, '0', blocks_sub_xx_0, '1']
- [virtual_source_5, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
